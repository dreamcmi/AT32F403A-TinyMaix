# Keil uVision project AT32F403A-TinyMaix.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403A-TinyMaix +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: AT32F403AVGT7
  c include: ..\cmsis\cm4\core_support;..\cmsis\cm4\device_support;..\drivers\inc;..\APP;..\TinyMaix;..\TinyMaix\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ../APP/: at32f403a_407_clock.c at32f403a_407_int.c main.c board.c
  group CMSIS
    ../cmsis/cm4/device_support/: system_at32f403a_407.c
    ../cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group Driver
    ../drivers/src/: at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_tmr.c
  group TinyMaix
    ../TinyMaix/: tm_layers.c tm_layers_O1.c tm_model.c tm_stat.c
